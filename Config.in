## Config.in
```kconfig
menu "Custom Packages"

source "$NERVES_DEFCONFIG_DIR/package/fbink/Config.in"

endmenu
```
